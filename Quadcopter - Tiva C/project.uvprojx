# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .;.\FreeRTOS\source\include;.\FreeRTOS\source\portable\RVDS\ARM_CM4F;D:\ti\TivaWare_C_Series-2.1.4.178\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_rvmdk.S main.c ADC_LIB.c GPIO_LIB.c InterruptHandlers_LIB.c LED_LIB.c PWM_LIB.c Timer_LIB.c UART_LIB.c mat.c MPU6050_LIB.c MPU6050_LIB.h I2C_LIB.c I2C_LIB.h MadgwickAHRS.c PID_LIB.c PID_LIB.h
    D:/ti/TivaWare_C_Series-2.1.4.178/driverlib/: adc.c gpio.c pwm.c sysctl.c timer.c uart.c
    D:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
  group FreeRTOS
    ./FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/Source/portable/MemMang/: heap_1.c
    ./: FreeRTOSConfig.h
